FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SECURITY_STRINGFORMAT:remove = "-Werror=format-security"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI = "file://ti-vision-11.00.00.06.tar.bz2"
SRC_URI[sha256sum] = "0eebe58270a56c388ad3d8cb23b44eb0492af2172992d1e758fa8c858b0d8b6c"

EXTRA_OEMAKE += " CROSS_COMPILE_LINARO=${TARGET_PREFIX} LINUX_SYSROOT_ARM=${STAGING_DIR_TARGET} TREAT_WARNINGS_AS_ERROR=0 GCC_LINUX_ARM_ROOT= GCC_LINUX_ARM_ROOT_A72= LINUX_FS_PATH=${STAGING_DIR_TARGET} SOC=${PLAT_SOC} LINUX_FS_STAGE_PATH=${D}"

do_compile() {
    oe_runmake yocto_build
}

